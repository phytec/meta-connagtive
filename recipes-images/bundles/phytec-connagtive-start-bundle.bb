require recipes-images/bundles/phytec-base-bundle.inc

RAUC_SLOT_rootfs = "phytec-connagtive-start-image"
